# Repository Jkillelea/Pi_Breakout_Board

## KiCad design Pi_Breakout_Board.kicad_pcb

Parts:
C1, C2, C4, C6, C7, C9, C10: 0.1U CERAMIC; C_1210_3225Metric_Pad1.42x2.65mm_HandSolder
C3, C5: 1uF; CP_EIA-3216-18_Kemet-A_Pad1.58x1.35mm_HandSolder
C8: 47uF 60V; CP_Radial_D6.3mm_P2.50mm
C11, C12, C13: 1uF 25V; C_1210_3225Metric_Pad1.42x2.65mm_HandSolder
D1, D2: LED GREEN; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D3: LED YELLOW; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D4: LED RED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D5: SMBJ5.0A
H1, H2, H3, H4: MountingHole; MountingHole_2.7mm_M2.5
J1: Raspberry_Pi_2_3; PinHeader_2x20_P2.54mm_Vertical
J2: Conn_02x04_Odd_Even heater header; PinHeader_2x04_P2.54mm_Vertical
J3: Conn_02x08_Odd_Even thermistor header; PinHeader_2x08_P2.54mm_Vertical
J4: Screw_Terminal_01x02; TerminalBlock_bornier-2_P5.08mm
J5, J6: Conn_01x08_Male; PinHeader_1x08_P2.54mm_Vertical
J7: Conn_01x02_Female; PinSocket_1x02_P2.54mm_Horizontal
J8: Conn_01x03_Male; PinHeader_1x03_P2.54mm_Vertical
Q1, Q2, Q3, Q4: Q_NMOS_GDSD; SOT-223
Q5: IRF9Z34 PMOS_GDS; TO-220-3_Vertical
R1, R2, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R20, R29: 10K; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R3, R4, R5, R6: 65R; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R19, R21, R22, R23, R24, R25, R26, R27: 18K 1%; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R28: 18K; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
TP1, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10: TestPoint; TestPoint_Pad_D2.0mm
U1: PCA9685PW; TSSOP-28_4.4x9.7mm_P0.65mm
U2: ADC128D818; TSSOP-16_4.4x5mm_P0.65mm

Connections:
28V: C8.1, C11.1, J2.2, J2.4, J2.6, J2.8, Q5.3 (S), R29.1
+3V3: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C9.1, D1.2 (A), J1.1 (3V3), J1.17 (3V3), J5.3, J6.3, J8.4, R2.2, R9.1, R10.1, R11.1, R12.1, R13.1, R14.1, R19.1, R21.1, R22.1, R23.1, R24.1, R25.1, R26.1, R27.1, U1.28 (VDD), U2.1 (VREF), U2.5 (V+)
+5V: C10.1, D5.1 (K), J1.2 (5V), J1.4 (5V), J7.1
/ch0: J3.1, R19.2, U2.16 (IN0)
/ch1: J3.3, R21.2, U2.15 (IN1)
/ch2: J3.5, R22.2, U2.14 (IN2)
/ch3: J3.7, R23.2, U2.13 (IN3)
/ch4: J3.9, R24.2, U2.12 (IN4)
/ch5: J3.11, R25.2, U2.11 (IN5)
/ch6: J3.13, R26.2, U2.10 (IN6)
/ch7: J3.15, R27.2, U2.9 (IN7)
/inpt_hicurrent: J4.2, Q5.2 (D)
/pwr0: J2.1, Q1.2 (D), Q1.4 (D)
/pwr1: J2.3, Q2.2 (D), Q2.4 (D)
/pwr2: J2.5, Q3.2 (D), Q3.4 (D)
/pwr3: J2.7, Q4.2 (D), Q4.4 (D)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C13.2, D2.1 (K), D3.1 (K), D4.1 (K), D5.2 (A), J1.6 (GND), J1.9 (GND), J1.14 (GND), J1.20 (GND), J1.25 (GND), J1.30 (GND), J1.34 (GND), J1.39 (GND), J3.2, J3.4, J3.6, J3.8, J3.10, J3.12, J3.14, J3.16, J4.1, J5.4, J6.4, J7.2, J8.1, Q1.3 (S), Q2.3 (S), Q3.3 (S), Q4.3 (S), R1.2, R3.2, R7.2, R8.2, R15.2, R16.2, R17.2, R18.2, R20.2, R28.2, U1.14 (VSS), U2.4 (GND)
LED_GREEN: J1.12 (GPIO18/PWM0), R4.1
LED_RED: J1.18 (GPIO24), R6.1
LED_YELLOW: J1.16 (GPIO23), R5.1
MISO0: J1.21 (MISO0/GPIO9), J5.6, J6.6, TP1.1
MOSI0: J5.7, J6.7
unnamed: C11.2, C12.1
unnamed: C12.2, C13.1
unnamed: D1.1 (K), R3.1
unnamed: D2.2 (A), R4.2
unnamed: D3.2 (A), R5.2
unnamed: D4.2 (A), R6.2
unnamed: Q1.1 (G), R15.1, U1.6 (LED0)
unnamed: Q2.1 (G), R16.1, U1.7 (LED1)
unnamed: Q3.1 (G), R17.1, U1.8 (LED2)
unnamed: Q4.1 (G), R18.1, U1.9 (LED3)
unnamed: Q5.1 (G), R28.1, R29.2
unnamed: R1.1, U1.25 (EXTCLK)
unnamed: R2.1, U1.1 (A0), U1.3 (A2), U1.5 (A4)
unnamed: R7.1, U1.2 (A1), U1.4 (A3), U1.24 (A5)
unnamed: R20.1, U2.7 (A0), U2.8 (A1)
RXD: J1.10 (GPIO15/RXD), J8.2
SCL0: J1.28 (ID_SC/GPIO1), J5.1, R11.2, TP8.1, U2.3 (SCL)
SCL1: J1.5 (SCL/GPIO3), J6.1, R14.2, TP10.1, U1.26 (SCL)
SCLK0: J1.23 (SCLK0/GPIO11), J5.5, J6.5, TP3.1
SDA0: J1.27 (ID_SD/GPIO0), J5.2, R9.2, TP7.1, U2.2 (SDA)
SDA1: J1.3 (SDA/GPIO2), J6.2, R12.2, TP9.1, U1.27 (SDA)
TXD: J1.8 (GPIO14/TXD), J8.3
~CE0: J1.24 (~CE0~/GPIO8), J6.8, R13.2, TP6.1
~CE1: J1.26 (~CE1~/GPIO7), J5.8, R10.2, TP5.1
~OE: J1.32 (PWM0/GPIO12), R8.1, TP4.1, U1.23 (~OE)

Notes on the sheet:
Lepton 1 Header
Lepton 2 Header
UART Breakout Header
Heater input power - nominal 28V, 50V safe max
board corner holes
Heater Drivers
Property GA/Team OTheRS
Pi Breakout Board
1010101(R/~W) 0x55?
Power indicator
Power header
Status Indicators

Board: 2 copper layers, 56.5 x 65.0 mm, 75 parts (22 on the bottom side), 47 nets.

## Commit log

2019-02-11 first commit. Schematic, board outline, and component placement.
2019-02-11 move the PCA9865 from I2C1 to I2C0. Routing saga continues
2019-03-15 rev3 with corrected header placement in work
2019-03-18 remove MOSI line (unused)
2019-03-18 Add +5V power header
2019-03-18 Remove power lines from UART breakout header
2019-03-18 misc routing
2019-03-18 routing
2019-03-18 Routing updates
2019-03-20 Renaming + minor revs. Ready for spin 2
2019-03-21 Routing updates + double checks. Silkscreen
2019-03-23 latest
2019-03-23 Datasheets
2019-03-24 add TVS diode
2019-03-24 misc placement changes
2019-03-24 more routing updates + new gerbers generated. Ready to try and spin this
2019-03-25 misc
2019-03-25 Silkscreen
2019-03-27 misc routing changes + more groundplane vias, hopefully won't be used
2019-04-14 Add 3V VCC pin to UART header (oops, shoulda had that). Other misc routing changes
2019-04-23 Final commit before transfer to GA

Notices in the files:
parts and their libraries:
Copyright 2016 Accelerated Designs. All rights reserved.
